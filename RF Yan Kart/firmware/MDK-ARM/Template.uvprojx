# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F030K6 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x1000) IROM(0x08000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F0XX_HD,HSI_VALUE=8000000
  c include: ..\STM32F0xx_StdPeriph_Driver\inc;..\STM32F0xx_StdPeriph_Driver\src;..\STM32F0xx_StdPeriph_Driver;..\..\firmware
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Source
    ../: main.c startup_stm32f030.s system_stm32f0xx.c stm32f0xx_it.c Si7021.c 24l01.c delay.c spi.c
    ../STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_adc.c stm32f0xx_dma.c stm32f0xx_misc.c stm32f0xx_i2c.c stm32f0xx_spi.c stm32f0xx_exti.c stm32f0xx_syscfg.c stm32f0xx_pwr.c stm32f0xx_rtc.c stm32f0xx_tim.c stm32f0xx_dbgmcu.c
